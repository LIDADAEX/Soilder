# Keil uVision project Soilder.uvprojx, settings and files
target Soilder (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Soilder +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../User_Third_Party/eigen-3.3.9;../User_File
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: retarget.c main.c gpio.c can.c crc.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group UserCode/1_Middlewares/1_Driver
    ../User_File/1_Middleware/1_Driver/CAN/: drv_can.cpp drv_can.h
    ../User_File/1_Middleware/1_Driver/Math/: drv_math.cpp drv_math.h
    ../User_File/1_Middleware/1_Driver/TIM/: drv_tim.cpp drv_tim.h
    ../User_File/1_Middleware/1_Driver/UART/: drv_uart.cpp drv_uart.h
  group UserCode/1_Middlewares/2_Algorithm
    ../User_File/1_Middleware/2_Algorithm/PID/: alg_pid.cpp alg_pid.h
    ../User_File/1_Middleware/2_Algorithm/Queue/: alg_queue.cpp alg_queue.h
    ../User_File/1_Middleware/2_Algorithm/Slope/: alg_slope.cpp alg_slope.h
    ../User_File/1_Middleware/2_Algorithm/Timer/: alg_timer.cpp alg_timer.h
  group UserCode/1_Middlewares/3_Debug
    ../User_File/1_Middleware/3_Debug/: debug_log.cpp debug_log.h debug_cmd.cpp debug_cmd.h debug_fifo.cpp debug_fifo.h debug_cmd_interface.h debug_cmd_interface.cpp
  group UserCode/2_Device/Motor
    ../User_File/2_Device/Motor/Motor_DJI/: dvc_motor_dji.cpp dvc_motor_dji.h
    ../User_File/2_Device/Motor/Motor_DM/: dvc_motor_dm.cpp dvc_motor_dm.h
  group UserCode/2_Device/DR16
    ../User_File/2_Device/DR16/: dvc_dr16.cpp dvc_dr16.h
  group UserCode/2_Device/IMU
    ../User_File/2_Device/IMU/: dm_imu.cpp dm_imu.h
  group UserCode/2_Device/Referee
    ../User_File/2_Device/Referee/: dvc_referee.cpp dvc_referee.h
  group UserCode/3_Chariot/1_Module
    ../User_File/3_Chariot/1_Module/Chassis/: crt_chassis.cpp crt_chassis.h
  group UserCode/4_Interaction
    ../User_File/4_Interaction/: ita_robot.cpp ita_robot.h
  group UserCode/5_Task
    ../User_File/5_Task/: tsk_config_and_callback.cpp tsk_config_and_callback.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 6.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
